# Keil uVision project 炸弹（模块化）.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 炸弹（模块化）
  c flags: Optimize=8 SizeSpeed=1
  c include: .\头文件
  group Source Group 1
    ./: main.c
    ./源文件/: temp.c keys.c lcd.c mo1.c mo2.c mo3.c mo4.c mo5.c
